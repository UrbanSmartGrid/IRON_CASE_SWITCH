<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\POWER_HOT_SWAP.ewp</path>
  </project>
  <batchBuild />
</workspace>
